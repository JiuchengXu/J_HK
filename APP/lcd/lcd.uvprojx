# Keil uVision project lcd.uvprojx, settings and files
target SRC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lcd +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\..\OUT\lcd_output\@L.bin   ..\..\OUT\lcd_output\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,
  c include: ..\..\include;..\..\include\libstm32;..\..\include\libucos;..\..\stmlib\CMSIS;..\..\stmlib\startup;..\..\stmlib\StdPeriph_Driver;..\..\ucos\Cfg;.\gui\inc;.\gui\Config;..\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./: bsp.c ILI93xx.c keyboard.c lcd.c battery.c task_font.c display.c songti20.c main.c sram.c includes.h sunccess.c statistic.c
  group Common
    ../../common/: adx345.c beep.c bus.c esp8266.c i2c.c key.c led.c power.c rom_onboard.c spi_flash.c time.c usart.c download.c e2prom.c watch_dog.c
  group stmlib
    ../../stmlib/CMSIS/: core_cm3.c system_stm32f10x.c
    ../../stmlib/StdPeriph_Driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../stmlib/startup/: startup_stm32f10x_hd.s
  group ucos
    ../../ucos/Cfg/: os_app_hooks.c
    ../../ucos/CPU/: cpu_c.c cpu_core.c cpu_a.asm
    ../../ucos/LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c mutex.c
    ../../ucos/Ports/: os_cpu_c.c os_cpu_a.asm
    ../../ucos/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group GUI
    ./gui/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ./gui/OS/: GUI_X.c
    ./gui/Lib/: STemWin526_CM3_OS_Keil.lib
